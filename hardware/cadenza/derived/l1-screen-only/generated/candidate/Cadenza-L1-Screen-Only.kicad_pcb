# Repository SuperTapir/CadenzaOS

File README.md:

# Cadenza OS

**English** · [简体中文](README.zh-CN.md)

**Cadenza** is a personal interactive-device and creative platform by Tapir.
Its system, **Cadenza OS**, explores a portable 1-bit App/Runtime, system
interaction model, and animation language for resource-constrained hardware.
The current prototype targets the original LILYGO T-Embed (not the CC1101
edition).

https://github.com/user-attachments/assets/4cbb17ba-b52b-44dc-b557-88dd9fdf3d63

The walkthrough above includes sound and covers Launcher, Timer, the background
Timer indicator, System Menu, Motion, Settings, and Animation Gallery. The
current build also adds the SIGHT note-reading trainer. Cadenza supports the
T-Embed 320×170 and Sharp Memory LCD 400×240 display profiles.

> **Prototype status:** desktop, headless, and firmware build gates are in
> place. Encoder feel, display behavior, real frame rate, and speaker quality
> still require validation on an original T-Embed device.

> **Non-commercial hobby project:** Cadenza is a personal project made for the
> enjoyment of designing and building it. There is no plan to commercialize
> it, sell it, or turn it into a business.

## Motivation

A *cadenza* is a passage in music where a performer is given room for free
expression. That idea fits this project: a restrained and coherent device that
leaves space for small games, tools, animation, and interaction experiments.

Cadenza grows out of Tapir's deep affection for Playdate's design and art
direction—not simply for it as a handheld, but for it as a carefully designed
digital object: a reflective black-and-white display, direct physical input,
expressive motion, and a small set of features with a strong point of view.
Many Launcher behaviors, interaction rhythms, animations, and visual details
in Cadenza deliberately study and attempt to recreate how Playdate works and
feels. Rebuilding those ideas is a way to understand the craft behind them and
to carry that learning into a personal platform, rather than an attempt to run
or replace Playdate software.

The T-Embed is the first software and interaction prototype. The longer-term
hardware direction centers on a 400×240 Sharp `LS027B7DH01` Memory LCD and a
dedicated handheld design. The software is structured so the prototype proves
the platform without defining the final device.

## Highlights

- One 1-bit framebuffer, App/Runtime, and layout model shared by the 320×170
  T-Embed and 400×240 Sharp profiles;
- six built-in Apps—Launcher, Timer, SIGHT, Motion, Settings, and Animation
  Gallery—with encoder navigation, button input, a System Menu, and explicit
  return to Launcher;
- system-owned background Timer, expiry alert, session volume, Reduced Motion,
  and vertical or horizontal Launcher orientation;
- 18 semantic sound cues plus bounded 1–4 note MIDI playback, backed by the
  same 44.1 kHz, four-voice synthesis core in the SDL callback and T-Embed I²S
  task;
- allocation-free Tween, Timeline, Spring, transitions, camera effects,
  particles, and atlas animation state machines;
- an SDL3 desktop simulator, deterministic headless host, PNG/GIF capture,
  pixel snapshots, and tests for lifecycle, input, animation, audio, and system
  services.

Cadenza is currently a 1-bit interaction and animation runtime, not a complete
game engine. Physics, collision, tilemaps, ECS, and level systems are
deliberately out of scope.

## Quick start on macOS

```bash
brew install cmake sdl3
./tools/simulator.py run --profile t-embed --scale 2 --overlay
```

For the source-watching development loop:

```bash
./tools/simulator.py dev --profile t-embed --scale 2 --overlay
```

Common presentation options are `--profile t-embed|sharp`, `--scale 1..4`,
`--palette reflective|pure`, `--overlay`, and `--device-frame`. The default
`reflective` palette approximates a reflective Memory LCD; `pure` is for strict
black-and-white inspection. These options do not change the framebuffer,
captures, snapshot hashes, or firmware output.

## Desktop controls

| Input | Action |
| --- | --- |
| Mouse wheel or `Left` / `Right` | Rotate the encoder |
| Tap `Space` / `Enter` | Click the button |
| Hold `Space` / `Enter` | Open the System Menu |
| `F1` | Toggle the debug HUD |
| `F2` / `F3` | Pause or resume / single-step while paused |
| `F4` / `F5` | Toggle fixed/real step / cycle time scale |
| `F6` / `F7` | Capture PNG / start or stop PNG+GIF recording |

See [`docs/development.md`](docs/development.md) for complete controls, Timer
behavior, display options, and the Launcher Cover workflow.

## Build and verification

```bash
tools/check.sh host           # host build and full test suite
tools/check.sh desktop        # SDL3 build and launch smoke test
tools/check.sh firmware       # ESP-IDF 5.5 T-Embed primary (UAC+CDC)
tools/firmware_uac.sh flash   # flash primary firmware to T-Embed
tools/check.sh firmware-pio   # PlatformIO rollback (no UAC)
tools/check.sh all            # host + desktop + ESP-IDF firmware + diff
```

Primary firmware needs ESP-IDF v5.5 (`CADENZA_IDF_PATH` or `../esp-idf-v5.5`).
PlatformIO rollback (no microphone):

```bash
../.platformio-env/bin/pio run
../.platformio-env/bin/pio run --target upload
../.platformio-env/bin/pio device monitor --baud 115200
```

Create an ad-hoc-signed macOS development package with:

```bash
./tools/simulator.py package
```

The resulting `.app` and zip are intended for local or same-architecture Mac
development. They are not Developer ID signed or notarized releases.

## Hardware safety

The current pin configuration comes from the official original LILYGO T-Embed
configuration. **Do not flash it to a T-Embed CC1101.** Check the packaging and
board markings before using firmware from this repository.

## Development disclosure

Most source code in this repository has been generated and iterated with
**OpenAI Codex** under Tapir's direction. Tapir defines the product vision,
requirements, architecture decisions, review standards, and acceptance
criteria; Codex performs much of the implementation, refactoring,
documentation, and test authoring.

AI-generated code is not treated as independently trustworthy. Accepted
changes are reviewed and checked through builds, tests, snapshots, research
records, and hardware gates where hardware is available. Tapir remains the
project's author and maintainer and is responsible for the work accepted into
the repository.

## Acknowledgements

- Deepest thanks to [Panic](https://panic.com/) and the
  [Playdate](https://play.date/) team. Cadenza would not exist without the
  affection and respect Tapir has for Playdate's industrial design, art
  direction, interaction design, and animation craft. The project openly
  studies and attempts to recreate many of those interaction patterns and
  qualities. Cadenza remains an independent project, is not compatible with
  Playdate software, and is not endorsed by Panic. The vendored Playdate
  Roobert font subset is used under CC BY 4.0 as documented in
  [`THIRD_PARTY_NOTICES.md`](THIRD_PARTY_NOTICES.md).
- [LILYGO](https://www.lilygo.cc/) created the T-Embed hardware used for the
  first prototype and publishes the reference material used by the platform
  adapter.
- SDL3, U8g2, doctest, stb_image_write, and gif-h make the portable build,
  rendering, testing, and desktop tooling possible. Exact versions, source
  boundaries, and licenses are recorded in
  [`THIRD_PARTY_NOTICES.md`](THIRD_PARTY_NOTICES.md).

## Further reading

- [`docs/project-vision.md`](docs/project-vision.md): long-term goals,
  motivation, and hardware direction;
- [`docs/platform-architecture.md`](docs/platform-architecture.md): platform
  responsibilities and architectural boundaries;
- [`docs/development.md`](docs/development.md): development, testing, and
  simulator reference;
- [`docs/verification.md`](docs/verification.md): current evidence, gates, and
  device verification scripts;
- [`docs/engine-adoption-decision.md`](docs/engine-adoption-decision.md): engine
  and library adoption boundaries;
- [`docs/audio-reference-research.md`](docs/audio-reference-research.md): audio
  research and adoption decisions;
- [`docs/audio-asset-contract.md`](docs/audio-asset-contract.md): delivery and
  acceptance rules for future WAV assets.

## KiCad design hardware/cadenza/derived/l1-screen-only/generated/candidate/Cadenza-L1-Screen-Only.kicad_pcb

File hardware/cadenza/README.md:

# Cadenza 硬件派生工程

本目录保存从已打样运行的 OSHWHub ESP32-S3 掌机参考工程派生的 Cadenza 硬件与外壳。冻结下载证据仍在 `hardware/reference/oshwhub-project_jofcnupz/`，不会原位修改。

当前整体结论、继承/修改/风险/验证/缺失资料清单见 `PRODUCTION_READINESS.md`。

## 目录状态

- `golden-import/`：用户在 KiCad 10.0.4 GUI 中完成的完整 EasyEDA Pro V2 导入副本。该目录保持逐字节冻结，不做任何修改。
- `working-base/`：从 golden 副本生成的可工作基线；只修复 EasyEDA 辅助符号、网络别名和电源符号的 KiCad 语义，不改变参考 PCB 或 77 个真实器件。
- `derived/l1-screen-only/`：当前唯一 L1 工作副本；从 working-base 完整复制，初始
  39 个来源文件逐项哈希一致，PCB 与 golden 逐字节一致。范围只允许替换 Sharp 屏幕。
- `archive/l1-overextended-experiment-20260722/`：此前混入 USB、Power/Lock、测试点和
  额外布线的旧候选完整归档；不再作为 L1 母版。
- `electrical/`：Sharp、Power/Lock、USB、GPIO 和输入电气候选；未验证内容均保留候选状态。
- `mechanical/shared/`：Sharp 共享机械基准；`mechanical/l1-fit-check/`、
  `l2-input-candidates/`、`l2-printable-controls/` 与 `power-lock-candidates/` 保存非冻结
  结构方案和可切片试印件。
- `validation/`：断电测量、屏幕面包板步骤、结果模板和隔离的 ESP-IDF 测试固件。
- `gates/`：L1 修改边界与 EasyEDA 导入复合焊盘语义规范化工具。
- `manufacturing/`：嘉立创制造 profile 和相对参考板的 BOM 增删候选。
- `libraries/`：经数据手册核对、但尚未由实物方向冻结的本地 KiCad 候选库。
- `sourcing/`：FPC、Power/Lock 开关和新增被动件的厂家资料、LCSC/JLCPCB 快照与
  未冻结候选；库存必须在下单当天重查。
- 正式 `l1/`、`l2/`、`l3/` 生产候选目录只在对应实物门禁通过后建立；现有候选文件
  不因 STEP 可打开或碰撞为零而自动升级为生产版本。

## Golden-import 初始哈希

复制时与 `hardware/reference/.../gui-full-import/` 中用户保存版本逐字节一致：

| 文件 | SHA-256 |
|---|---|
| `.kicad_pro` | `bb2fdd73a376904e22bb7428891c3425cf2eff1e7907036c78450dab097cdb5a` |
| `.kicad_sch` | `58b74354140eec31b419619c28eb47a8e217f2e9ead8e09badaa112ca11785f3` |
| `.kicad_pcb` | `70a46bd100ed8184edcd2e90d3dbd21fff676999e0f3fa71cad1121c8c7b4101` |
| `.kicad_sym` | `74f14190bbd9206441116219ff4546007d31befe4790a2f30aaa2afad0deed13` |

## 修改原则

1. 先恢复 KiCad 原生语义并证明网表连通集合与参考 PCB 一致。
2. PCB 的 77 个封装、58 个网络、78 个过孔、506 段走线、130 × 60 mm 板框和关键坐标在 golden 门禁前保持不变。
3. 任何功能变化进入 L1/L2 目录，并记录继承、修改、依据、风险和验证。
4. ERC/DRC 数字只能作为证据之一，不能单独证明可靠或否定参考实物。
5. 最终必须回导嘉立创 EDA，核对 BOM/CPL、封装、铜皮、3D 和生产预览。

## 当前最近的人工门禁

先执行 `validation/physical-evidence/MEASUREMENT_SESSION.md` 的**全程断电**测量，
确认 FPC 触点/Pin 1/十针连续性，并测量 EC12 与按键。之后才允许冻结 FPC 座、
旋钮、键帽和 Power/Lock 位置，再进行屏幕上电验证与正式 KiCad 功能修改。
辅助打印件位于 `output/pdf/cadenza-physical-fit-sheets-a4.pdf`；必须按 100% 打印并先
核对 10/50 mm 校准尺，打印对位不能替代断电通断测量。

## 当前可重复候选门禁

统一入口：`python3 hardware/cadenza/gates/current-candidate/run_current_candidate_gates.py`。
它在临时镜像中运行会写结果的检查，并对 golden、working-base、参考 STEP 和 OpenSpec
做运行前后哈希保护；`PASS_CANDIDATE` 明确不等于 production ready。

- Sharp 电气映射：`electrical/display/verify_l1_display_baseline.py` → PASS。
- L1 外壳与四种 FPC 方向：`mechanical/l1-fit-check/audit_l1_fitcheck.py` → PASS，
  12 个有效 STEP、最大硬碰撞 `0 mm³`、`selection_frozen=false`。
- FPC KiCad 10 隔离库：`libraries/display-fpc-variants/verify_library.py` → PASS，
  三个候选均可由 KiCad 10 解析；两个模型明确为 `PROXY`。
- FPC 1:1 核对纸：`validation/physical-evidence/fit-sheets/verify_fit_sheets.py` → PASS，
  四页 A4 PDF 已逐页渲染检查，且继续保持 `orientation_frozen=false`。
- L2 输入 RC：`electrical/input/spice/run_spice.py` → 3/3 容差角落 PASS；这只验证
  理想候选电路，不替代真实 EC12 脉宽、相序与抖动测量。
- L2 输入验证固件：`validation/l2-input-firmware/` 的 host tests 与 ESP-IDF 5.5 构建
  PASS，未刷写；真实脚位、方向、每卡点计数仍需实物验证。
- L2 可打印控制件：21 个 STEP + 21 个封闭 STL、三布局 × 三轴接口候选验证 PASS；
  `production_ready=false`，真实轴型和行程测量前只可用于试印。
- S1 Power/Lock：厂家页 1 尺寸的专用 footprint 与两个边缘位置 fit-check 均通过；
  `H035=3.50 mm` 已按 Y 前后总深度建模，10 个 STEP 有效、修正后硬碰撞仍为 0，
  但按钮帽、手感、后壳和完整 Z-stack 未验证，`selection_frozen=false`。
- L1 原理图修改合同：参考 77 个器件/102 个网络完整分区，47/47 自检 PASS。
- L1 dry-run 调查：`analysis/L1_SCHEMATIC_DRYRUN_FEASIBILITY.md` 确认可在完整隔离副本
  中实施；使用 KiCad 10 GUI 与 ERC 差分，不能把导入型 ERC 强行清零。
- L1 隔离副本编辑前基线：KiCad 10.0.4 可重新导出 77 个器件、102 个网络、691 项
  导入型 ERC 和一页 A3 PDF；PDF 已渲染目视检查。该结果只证明副本完整可读。
- L1 候选网表门禁：11 个 synthetic 正反 fixture 自测通过；正式两页 KiCad 原理图候选
  又以真实 KiCad XML 网表通过 20/20，`real_candidate_validated=true`。这只证明原理图
  结构/网络；`pcb_synced=false`、`fpc_selection_frozen=false`、`production_ready=false`。
- ERC error 稳定差分：导入基线 18 → 正式候选 14，新增 0、旧显示删除带走 4；
  585 个 warning 和 14 个继承 error 仍需按风险处置，不能称为生产 ERC 通过。
- PCB 同步前置检查：新增 26 个器件已有 24 个 footprint；H1/Q1 丢失元数据已按
  参考 PCB 精确恢复，只剩 `J_DISP1` 与 `SW_PWR1` 必须等实物冻结。
- L2 输入、Power/Lock 和 USB 的 GPIO/器件仍是候选；正式 PCB 尚未建立，因而当前
  不存在可下单 Gerber、生产 BOM 或 CPL。
- 嘉立创桌面端回导副本保留 77 个封装和主要几何，但所有 PCB 网络归属为空；详见
  `roundtrip/easyeda-pro/ROUNDTRIP_AUDIT.md`。15 处 `Arial` 字体告警本身只影响文字，
  网络丢失才是禁止把该 `.eprj2` 当电气主工程的原因。

Parts:
BOOT1: TS36CA-0.6; SW-SMD_TS36CA; Voltage Rating (DC) 12V; Manufacturer Part TS36CA-0.6; LCSC Part Name 轻触开关 3*6*3.5侧按 直径0.6定位柱 白体黑头 250力度
C1, C6, C7, C8, C9: 22uF; C0805; Tolerance ±20%; Voltage Rating 25V; Manufacturer Part CL21A226MAQNNNE; LCSC Part Name 22uF ±20% 25V
C2, C4, C11, C13, C18, C20, C22, C23, C26: 10uF; C0805; Tolerance ±10%; Voltage Rating 25V; Manufacturer Part CGA0805X5R106K250MT; LCSC Part Name 10uF ±10% 25V
C3, C5: 22uF; C0805; Manufacturer Part CL21A226MAQNNNE; LCSC Part Name 22uF ±20% 25V
C10, C12, C14, C16, C17, C19, C21, C24, C25: 100nF; C0805; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part FCC0805B104K500DT; LCSC Part Name 100nF ±10% 50V
C15: 1uF; C0805; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part CGA0805X7R105K500MT; LCSC Part Name 1uF ±10% 50V
CARD1: TF PUSH; TF-SMD_TF-PUSH; Manufacturer Part TF PUSH; LCSC Part Name 自弹式 MicroSD卡(TF卡) 卡座
CN1: HC-1.25-2PWT; CONN-SMD_2P-P1.25-HC-1.25-2PWT; Current Rating (Max) 1A; Rated Voltage (Max) 125V; Manufacturer Part HC-1.25-2PWT; LCSC Part Name 1x2P 间距:1.25mm 卧贴 系列:PicoBlade(MX 1.25)
H1: WAFER-PH2.0-2PWB; Current Rating 2A; Current Rating (Max) 2A; Manufacturer Part WAFER-PH2.0-2PWB; LCSC Part Name 1x2P 间距:2mm 卧贴
KEY1, KEY2, KEY3, KEY4, KEY5, KEY6: HX TS665WS 200gf; KEY-SMD_L6.0-W6.0-LS6.6; Voltage Rating 12V; Manufacturer Part HX TS665WS 200gf; LCSC Part Name 6*6*5mm 贴片 轻触开关
L1: 1uH; L0805; Manufacturer Part MLP2012S1R0MT0S1; LCSC Part Name 1uH ±20%
L2: 2.2uH; IND-SMD_L3.0-W3.0_FNR30XXS; Manufacturer Part FNR3015S2R2MT; LCSC Part Name 2.2uH ±20% 2A
LED1: XL-2012UOC; LED0805-RD_ORANGE; Manufacturer Part XL-2012UOC; LCSC Part Name 0805橙贴片式发光二极管
LED2: XL-2020RGBC-2812B; LED-SMD_4P-L2.0-W2.0-BR-1; Manufacturer Part XL-2020RGBC-2812B; LCSC Part Name 幻彩透明 XL-2020RGBC-WS2812B
Q1: UMH3N; Manufacturer Part UMH3N; LCSC Part Name 2个NPN-预偏置 100mA 50V
R1, R2: 5.1kΩ; R0805; Overload Voltage (Max) 150V; Tolerance ±1%; Manufacturer Part 0805W8F5101T5E; LCSC Part Name 5.1kΩ ±1% 125mW 厚膜电阻
R3, R8, R12, R15: 100kΩ; R0805; Overload Voltage (Max) 150V; Tolerance ±1%; Manufacturer Part 0805W8F1003T5E; LCSC Part Name 100kΩ ±1% 125mW 厚膜电阻
R4: 2Ω; R0805; Manufacturer Part FRC0805J2R0TS; LCSC Part Name 2Ω ±5% 125mW 厚膜电阻
R5: 500mΩ; R0805; Manufacturer Part FRL0805JR500TS; LCSC Part Name 500mΩ ±5% 125mW 厚膜电阻
R6: 680kΩ; R0805; Manufacturer Part 0805W8F6803T5E; LCSC Part Name 680kΩ ±1% 125mW 厚膜电阻
R7: 1kΩ; R0805; Overload Voltage (Max) 150V; Tolerance ±1%; Manufacturer Part 0805W8F1001T5E; LCSC Part Name 1kΩ ±1% 125mW 厚膜电阻
R9: 150kΩ; R0805; Manufacturer Part 0805W8F1503T5E; LCSC Part Name 150kΩ ±1% 125mW 厚膜电阻
R10, R11, R16, R17, R18: 10kΩ; R0805; Overload Voltage (Max) 150V; Tolerance ±5%; Manufacturer Part FRC0805J103TS; LCSC Part Name 10kΩ ±5% 125mW 厚膜电阻
R19: 22Ω; R0805; Tolerance ±1%; Voltage-Supply(Max) 150V; Manufacturer Part 0805W8F220JT5E; LCSC Part Name 22Ω ±1% 125mW 厚膜电阻
RST1: TS36CA-0.6; SW-SMD_TS36CA; Voltage Rating (DC) 12V; Manufacturer Part TS36CA-0.6; LCSC Part Name 轻触开关 3*6*3.5侧按 直径0.6定位柱 白体黑头 250力度
SCREW1, SCREW2, SCREW3, SCREW4: M2螺丝
SW1: SK12D07VG4-BF; SW-TH_SK12D07VG4-BF; Manufacturer Part SK12D07VG4-BF; LCSC Part Name SK12D07VG4耐温过波峰焊
SW2: 10*10*9-6P WX; SW-SMD-6P-L10.5-W10.0_C2858290; Manufacturer Part 10*10*9-6P WX; LCSC Part Name 10*10*9-6P贴片五向开关编带
U1: IP5306; ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP; Voltage - Supply 4.65V~5.5V; Manufacturer Part IP5306; LCSC Part Name 集成2.1A充电器和2.1A放电器的全集成移动电源系统级芯片
U2: TLV62568DBVR; SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR; Manufacturer Part TLV62568DBVR; LCSC Part Name 1A高效同步降压转换器
U3: CH340C; SOP-16_L10.0-W3.9-P1.27-LS6.0-BL; Voltage - Supply 3.3V；5V; Manufacturer Part CH340C; LCSC Part Name CH340C
U4: ESP32-S3-WROOM-1-N16R8; WIRELM-SMD_ESP32-S3-WROOM-1; Manufacturer Part ESP32-S3-WROOM-1-N16R8; LCSC Part Name 通用型Wi-Fi+低功耗蓝牙MCU模组
U5: MAX98357AETE+T; TQFN-16_L3.0-W3.0-P0.50-BL-EP1.5; Voltage - Supply 2.5V~5.5V; Manufacturer Part MAX98357AETE+T; LCSC Part Name 微型、低成本、PCM 类 D 级放大器具有 AB 级性能
U7: ICS-43434; MIC-SMD_6P-L3.5-W2.7-P0.90-BL; Voltage - Supply 1.65V~3.63V; Manufacturer Part ICS-43434; LCSC Part Name ICS-43434
USB1: HX-TYPE-C 16P 180 LC-B H15.0; USB-C-TH_HX-TYPE-C-16P-180LC-BH15.0; Current Rating-Power 3A; Voltage Rating 20V; Manufacturer Part HX-TYPE-C 16P 180 LC-B H15.0; LCSC Part Name Type-C 母 直插

Connections:
3V3M: C1.2, C11.2, C12.2, C13.2, C14.2, C22.1, C23.1, C24.1, C25.1, C26.2, CARD1.4 (VDD), L2.2, LED2.4 (VDD), R6.2, R10.2, R11.1, R12.2, R16.2, R17.2, R18.2, U3.4 (V3), U3.16 (VCC), U4.2 (3V3), U7.5 (VDD)
$1N34554: R1.1, USB1.A5 (CC1)
$1N34556: R2.2, USB1.B5 (CC2)
$1N34586: C5.2, R5.1, U1.6 (BAT)
$1N34588: L1.1, U1.7 (SW)
$1N34595: LED1.2 (+), U1.2 (LED1)
$1N34601: R7.1, U1.3 (LED2), U1.4 (LED3)
$1N34619: C4.2, R4.1
$1N34652: L2.1, U2.3 (SW)
$1N34657: R6.1, R9.2, U2.5 (FB)
$1N34720: CN1.1, U5.9 (OUTP)
$1N34722: CN1.2, U5.10 (OUTN)
$1N34731: R12.1, U5.4 (SD_MODE#)
$1N34770: CARD1.5 (CLX), R19.2
+5V: C8.2, C9.2, C10.2, C18.1, C19.1, C20.2, C21.1, SW1.3, U2.1 (EN), U2.4 (VIN), U5.7 (VDD), U5.8 (VDD); also elsewhere on the board
BAT+: C3.2, H1.1, L1.2, R3.2, R5.2, R7.2
CHIP_PU: C15.2, C17.1, Q1.6 (C), R10.1, RST1.C, U4.3 (EN)
D+: U3.5 (D+), USB1.A6 (DP1), USB1.B6 (DP2)
D-: U3.6 (D-), USB1.A7 (DN1), USB1.B7 (DN2)
DTR: Q1.2 (B), Q1.3 (C), U3.13 (DTR#)
GND: BOOT1.D, C1.1, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.2, C17.2, C18.2, C19.2, C20.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.1, CARD1.6 (VSS), CARD1.10, CARD1.11, CARD1.12, CARD1.13, H1.2, KEY1.2, KEY2.2, KEY3.2, KEY4.2, KEY5.2, KEY6.2, LED1.1 (-), LED2.2 (GND), R1.2, R2.1, R8.1, R9.1, R15.2, RST1.D, SW2.4, U1.9 (EP), U2.2 (GND), U3.1 (GND), U4.1 (GND), U4.40 (GND), U4.41 (GND), U5.2 (GAIN_SLOT), U5.3 (GND), U5.11 (GND), U5.15 (GND), U5.17 (EP), U7.2 (LR), U7.3 (GND), USB1.A1 (GND), USB1.A12 (GND), USB1.B1 (GND), USB1.B12 (GND); also elsewhere on the board
GPIO0: BOOT1.C, C16.1, Q1.4 (E), R11.2, U4.27 (IO0)
GPIO1: U4.39 (IO1), U7.1 (WS)
GPIO2: U4.38 (IO2), U7.4 (SCK)
GPIO4: R3.1, R8.2, U4.4 (IO4)
GPIO5: KEY6.1, U4.5 (IO5)
GPIO6: SW2.5, U4.6 (IO6)
GPIO7: SW2.1, U4.7 (IO7)
GPIO8: KEY2.1, U4.12 (IO8)
GPIO9: CARD1.7 (DAT0), R16.1, U4.17 (IO9)
GPIO10: CARD1.2 (CD/DAT3), R18.1, U4.18 (IO10)
GPIO11: CARD1.3 (CMD), R17.1, U4.19 (IO11)
GPIO12: U4.20 (IO12); also elsewhere on the board
GPIO13: R19.1, U4.21 (IO13)
GPIO14: U4.22 (IO14); also elsewhere on the board
GPIO15: KEY5.1, U4.8 (IO15)
GPIO16: KEY3.1, U4.9 (IO16)
GPIO17: KEY4.1, U4.10 (IO17)
GPIO18: KEY1.1, U4.11 (IO18)
GPIO19: SW2.2, U4.13 (IO19)
GPIO20: SW2.3, U4.14 (IO20)
GPIO21: R15.1, U4.23 (IO21), U7.6 (SD)
GPIO38: LED2.3 (DI), U4.31 (IO38)
GPIO39: U4.32 (IO39); also elsewhere on the board
GPIO40: U4.33 (IO40), U5.1 (DIN)
GPIO41: U4.34 (IO41), U5.16 (BCLK)
GPIO42: U4.35 (IO42), U5.14 (LRCLK)
GPIO47: U4.24 (IO47); also elsewhere on the board
GPIO48: U4.25 (IO48); also elsewhere on the board
RTS: Q1.1 (E), Q1.5 (B), U3.14 (RTS#)
U0RXD: U3.2 (TXD), U4.36 (RXD0)
U0TXD: U3.3 (RXD), U4.37 (TXD0)
VBUS: C2.2, R4.2, U1.1 (VIN), USB1.A4 (VBUS), USB1.A9 (VBUS), USB1.B4 (VBUS), USB1.B9 (VBUS)
VOUT: C6.2, C7.2, SW1.2, U1.8 (VOUT)

Notes on the sheet:
ESP32-S3
DISP - GPIO39 DISP_SI - GPIO12 DISP_SCLK - GPIO48 DISP_EXTCOMIN - GPIO47 DISP_SCS - GPIO14
电池管理
麦克风（实际使用ZTS6672）
SD_CMD - GPIO11 SD_CLK - GPIO13 SD_DATA - GPIO9 SD_CD - GPIO10
MIC_WS - GPIO1 MIC_SCK - GPIO2 MIC_DIN - GPIO21
BAT - GPIO4
STATUS_LED - GPIO38
SD_CMD - GPIO11 SD_CLK - GPIO13 SD_DATA - GPIO9 SD_CD - GPIO10 SPK_DOUT - GPIO40 SPK_BCLK - GPIO41 SPK_LRCK - GPIO42 KEY_BOOT - GPIO0 KEY_MENU - GPIO18 KEY_OPTION - GPIO8 KEY_SELECT - GPIO16 KEY_START - GPIO17 KEY_A - GPIO15 KEY_B - GPIO5 KEY_LEFT - GPIO19 KEY_RIGHT - GPIO6 KEY_UP - GPIO7 KEY_DOWN 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
Type-C（实际使用C49261586， 原理图相同，但高度不同，购买时注意）
自动下载
Sharp LS027B7DH01 Memory LCD
SD卡
SPK_DOUT - GPIO40 SPK_BCLK - GPIO41 SPK_LRCK - GPIO42
主电路BUCK
CH340C
状态指示灯
KEY_BOOT - GPIO0 KEY_MENU - GPIO18 KEY_OPTION - GPIO8 KEY_SELECT - GPIO16 KEY_START - GPIO17 KEY_A - GPIO15 KEY_B - GPIO5 KEY_LEFT - GPIO19 KEY_RIGHT - GPIO6 KEY_UP - GPIO7 KEY_DOWN - GPIO20

Parts:
C_DISP1: 100nF; C0805; Tolerance ±10%; Voltage Rating 50V; Manufacturer Part FCC0805B104K500DT; JLCPCB Part Class Extended Part
J_DISP1: FH34SRJ-10S-0.5SH(50); Hirose_FH34SRJ-10S-0.5SH_50_1x10_P0.50mm_DualContact; Manufacturer Part FH34SRJ-10S-0.5SH(50); JLCPCB Part Class Extended Part

Connections:
+5V: J_DISP1.6, J_DISP1.7, J_DISP1.8; also elsewhere on the board
GND: C_DISP1.2, J_DISP1.9, J_DISP1.10, J_DISP1.MP; also elsewhere on the board
GPIO12: C_DISP1.1, J_DISP1.5; also elsewhere on the board
GPIO14: J_DISP1.4; also elsewhere on the board
GPIO39: J_DISP1.1; also elsewhere on the board
GPIO47: J_DISP1.3; also elsewhere on the board
GPIO48: J_DISP1.2; also elsewhere on the board

Board: 2 copper layers, 130.0 x 60.0 mm, 74 parts (8 on the bottom side), 54 nets.

File hardware/cadenza/derived/l1-screen-only/generated/manufacturing-provisional/Cadenza-L1-JLCPCB-BOM.csv:

Comment,Designator,Footprint,LCSC Part #
TS36CA-0.6,BOOT1,SW-SMD_TS36CA,C2681481
22uF,C1,C0805,C45783
100nF,C10,C0805,C5137467
10uF,C11,C0805,C6119887
100nF,C12,C0805,C5137467
10uF,C13,C0805,C6119887
100nF,C14,C0805,C5137467
1uF,C15,C0805,C6119929
100nF,C16,C0805,C5137467
100nF,C17,C0805,C5137467
10uF,C18,C0805,C6119887
100nF,C19,C0805,C5137467
10uF,C2,C0805,C6119887
10uF,C20,C0805,C6119887
100nF,C21,C0805,C5137467
10uF,C22,C0805,C6119887
10uF,C23,C0805,C6119887
100nF,C24,C0805,C5137467
100nF,C25,C0805,C5137467
10uF,C26,C0805,C6119887
22uF,C3,C0805,C45783
10uF,C4,C0805,C6119887
22uF,C5,C0805,C45783
22uF,C6,C0805,C45783
22uF,C7,C0805,C45783
22uF,C8,C0805,C45783
22uF,C9,C0805,C45783
TF PUSH,CARD1,TF-SMD_TF-PUSH,C393941
HC-1.25-2PWT,CN1,CONN-SMD_2P-P1.25-HC-1.25-2PWT,C2845379
100nF,C_DISP1,C0805,C5137467
WAFER-PH2.0-2PWB,H1,CONN-SMD_2P-P2.00_XUNPU_WAFER-PH2.0-2PWB,C3029440
FH34SRJ-10S-0.5SH(50),J_DISP1,Hirose_FH34SRJ-10S-0.5SH_50_1x10_P0.50mm_DualContact,C324723
HX TS665WS 200gf,KEY1,KEY-SMD_L6.0-W6.0-LS6.6,C5143657
HX TS665WS 200gf,KEY2,KEY-SMD_L6.0-W6.0-LS6.6,C5143657
HX TS665WS 200gf,KEY3,KEY-SMD_L6.0-W6.0-LS6.6,C5143657
HX TS665WS 200gf,KEY4,KEY-SMD_L6.0-W6.0-LS6.6,C5143657
HX TS665WS 200gf,KEY5,KEY-SMD_L6.0-W6.0-LS6.6,C5143657
HX TS665WS 200gf,KEY6,KEY-SMD_L6.0-W6.0-LS6.6,C5143657
1uH,L1,L0805,C383371
2.2uH,L2,IND-SMD_L3.0-W3.0_FNR30XXS,C167747
XL-2012UOC,LED1,LED0805-RD_ORANGE,C965813
XL-2020RGBC-2812B,LED2,LED-SMD_4P-L2.0-W2.0-BR-1,C5349955
UMH3N,Q1,SC-70-6_L2.2-W1.3-P0.65-LS2.1-BR,C62892
5.1kΩ,R1,R0805,C27834
10kΩ,R10,R0805,C2930231
10kΩ,R11,R0805,C2930231
100kΩ,R12,R0805,C149504
100kΩ,R15,R0805,C149504
10kΩ,R16,R0805,C2930231
10kΩ,R17,R0805,C2930231
10kΩ,R18,R0805,C2930231
22Ω,R19,R0805,C17561
5.1kΩ,R2,R0805,C27834
100kΩ,R3,R0805,C149504
2Ω,R4,R0805,C2930265
500mΩ,R5,R0805,C2934281
680kΩ,R6,R0805,C17797
1kΩ,R7,R0805,C17513
100kΩ,R8,R0805,C149504
150kΩ,R9,R0805,C17470
TS36CA-0.6,RST1,SW-SMD_TS36CA,C2681481
SK12D07VG4-BF,SW1,SW-TH_SK12D07VG4-BF,C49451756
10*10*9-6P WX,SW2,SW-SMD-6P-L10.5-W10.0_C2858290,C2858290
IP5306,U1,ESOP-8_L4.9-W3.9-P1.27-LS6.0-BL-EP,C181692
TLV62568DBVR,U2,SOT-23-5_L3.0-W1.7-P0.95-LS2.8-BR,C163219
CH340C,U3,SOP-16_L10.0-W3.9-P1.27-LS6.0-BL,C84681
ESP32-S3-WROOM-1-N16R8,U4,WIRELM-SMD_ESP32-S3-WROOM-1,C2913202
MAX98357AETE+T,U5,TQFN-16_L3.0-W3.0-P0.50-BL-EP1.5,C910544
ICS-43434,U7,MIC-SMD_6P-L3.5-W2.7-P0.90-BL,C5656610
HX-TYPE-C 16P 180 LC-B H15.0,USB1,USB-C-TH_HX-TYPE-C-16P-180LC-BH15.0,C49261588

## KiCad design hardware/rev-a/product-d1/kicad/encoder-a/cadenza-encoder-a.kicad_pcb

File hardware/rev-a/product-d1/kicad/encoder-a/README.md:

# Cadenza D1 Encoder + A Daughterboard

This 34 mm x 38 mm, two-layer daughterboard implements the right-side primary
control as one replaceable assembly:

- ALPS Alpine EC12D1524403 incremental encoder, 30 detents / 15 pulses
- axial encoder push switch mapped to `A_SW`
- local 10 kOhm / 10 nF debounce networks for A, B, and A_SW
- reserved `LED_CTRL` line for a future illuminated-knob revision
- JST-SH 1.0 mm six-pin cable to the main board
- four M2 mounting holes and a 28 mm maximum knob envelope

## Frozen interface

| J1 pin | Net | Direction at daughterboard |
| --- | --- | --- |
| 1 | +3V3 | input |
| 2 | GND | return |
| 3 | ENC_A | output, active low |
| 4 | ENC_B | output, active low |
| 5 | A_SW | output, active low |
| 6 | LED_CTRL / RESERVED | no-connect on D1 daughterboard |

The cable pin order must match main-board J6 exactly. Do not reverse the cable
at assembly time; pin 1 is marked on both boards.

## Mechanical stack

- PCB: 34.0 x 38.0 x 1.6 mm, nominal.
- Encoder shaft axis: X=17.0 mm, Y=17.0 mm from the board upper-left datum.
- Knob: 28.0 mm maximum OD, 6.0 mm D-shaft bore, axial movement at least
  0.5 mm, and 0.6 mm radial clearance to the front-shell aperture.
- Front shell must react encoder bushing load; the PCB screws are alignment and
  anti-rotation features, not the sole push-load path.
- J1 is on the back side at the lower edge. Reserve 8 mm cable bend clearance.
- M2 holes are centered 3 mm from each board corner. Use M2 x 4 heat-set inserts
  in the front shell and M2 x 5 screws from the rear.

## Manufacturing intent

The encoder is through-hole and should be hand/secondary soldered after SMT
assembly. J1 and the debounce passives are JLCPCB-assemblable. Import the generated
`cadenza-encoder-a.kicad_pcb` directly into EasyEDA Pro, then verify pin 1,
board outline, plated slots, and the encoder courtyard against this document.

Regenerate with:

```sh
python3 generate.py
```

Parts:
C1, C2, C3: 10n; C_0603_1608Metric
J1: JST-SH-6; JST_SH_SM06B-SRSS-TB
R1, R2, R3: 10k; R_0603_1608Metric
SW1: EC12D1524403; ALPS_EC12D1524403

Connections:
+3V3: J1.1, R1.1, R2.1, R3.1
A_SW: C3.1, J1.5, R3.2, SW1.D (A_SW)
ENC_A: C1.1, J1.3, R1.2, SW1.A (ENC_A)
ENC_B: C2.1, J1.4, R2.2, SW1.B (ENC_B)
GND: C1.2, C2.2, C3.2, J1.2, SW1.6, SW1.7, SW1.C (ENC_COM), SW1.E (SW_COM)
LED_CTRL: J1.6

Notes on the sheet:
LED_CTRL is reserved and intentionally no-connect on the D1 daughterboard.
J1: 1=+3V3 2=GND 3=ENC_A 4=ENC_B 5=A_SW 6=LED_CTRL
SW1 axial push is the front-panel A button. Encoder common and switch common return to GND.
R1/C1, R2/C2, R3/C3: 10k pull-up and 10nF debounce. Firmware still performs state-machine debounce.

Board: 2 copper layers, 34.0 x 38.0 mm, 12 parts (7 on the bottom side), 5 nets.

Other parts of the board:
H1, H2, H3, H4: M2; MountingHole_2.2mm

File hardware/rev-a/product-d1/kicad/encoder-a/bom.csv:

Reference,Qty,Value,MPN,LCSC,Assembly
SW1,1,30 detent / 15 pulse encoder with push,EC12D1524403,C112349,Hand/THT
J1,1,JST-SH 6 pin horizontal,SM06B-SRSS-TB,C160404,JLC SMT
"R1,R2,R3",3,10k 1% 0603,generic,TBD basic,JLC SMT
"C1,C2,C3",3,10nF 16V X7R 0603,generic,TBD basic,JLC SMT
